# IAR project sample_netx_duo_ping.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; USE_STM32L4S5I_IOT01; WIFI_SSID="<YOUR-WIFI-SSID>"; WIFI_PASSWORD="<YOUR-WIFI-PASSWORD>"; WIFI_SECURITY_TYPE=WIFI_ECN_WPA2_PSK
  ICCARM.CCIncludePath2: ..\threadx\common\inc; ..\threadx\ports\cortex_m4\iar\inc; ..\netxduo\common\inc; ..\netxduo\ports\cortex_m4\iar\inc; ..\netxduo\addons\dns; ..\netxduo\addons\mqtt; ..\netxduo\nx_secure\inc; ..\netxduo\crypto_libraries\inc; ..\netxduo\nx_secure\ports; ..\stm32l4xx_lib\; ..\stm32l4xx_lib\CMSIS\Include; ..\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ..\common_hardware_code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sample_netx_duo_ping.out
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common source
    ../common_hardware_code/: board_setup.c es_wifi.c startup_stm32l4s5xx.s tx_initialize_low_level.s wifi.c wifi.h
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: nx_driver_stm32l4.c nx_driver_stm32l4.h sample_netx_duo_ping.c
