# IAR project sample_pnp_temperature_controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; WIFI_SSID="<YOUR-WIFI-SSID>"; WIFI_PASSWORD="<YOUR-WIFI-PASSWORD>"; WIFI_SECURITY_TYPE=WIFI_ECN_WPA2_PSK; SAMPLE_WAIT_OPTION=(20 * NX_IP_PERIODIC_RATE)
  ICCARM.CCIncludePath2: ..\threadx\common\inc; ..\threadx\ports\cortex_m4\iar\inc; ..\netxduo\common\inc; ..\netxduo\ports\cortex_m4\iar\inc; ..\netxduo\nx_secure\ports; ..\netxduo\crypto_libraries\inc; ..\netxduo\common\; ..\netxduo\addons\cloud; ..\netxduo\addons\dns; ..\netxduo\addons\mqtt; ..\netxduo\addons\sntp; ..\netxduo\nx_secure\inc; ..\netxduo\nx_secure\ports; ..\common_hardware_code; ..\stm32l4xx_lib\; ..\stm32l4xx_lib\CMSIS\Include; ..\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ..\common_hardware_code; ..\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\netxduo\addons\azure_iot\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.bin
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F746xx; DISABLE_GUIX; TX_ENABLE_EXECUTION_CHANGE_NOTIFY; ENDPOINT=$PIPELINE_DPS_ENDPOINT$; ID_SCOPE=$PIPELINE_ID_SCOPE$; REGISTRATION_ID=$PIPELINE_REGISTRATION_ID$; HOST_NAME=$PIPELINE_HOST_NAME$; DEVICE_ID=$PIPELINE_DEVICE_ID$; DEVICE_SYMMETRIC_KEY=$PIPELINE_DEVICE_SYMMETRIC_KEY$; DEVICE_CERT=$PIPELINE_DEVICE_CERTIFICATE$; DEVICE_PRIVATE_KEY=$PIPELINE_DEVICE_PRIVATE_KEY$; USE_DEVICE_CERTIFICATE=$PIPELINE_USE_DEVICE_CERTIFICATE$; $PIPELINE_DISABLE_DPS_SAMPLE$; $PIPELINE_DISABLE_TELEMETRY_SAMPLE$; $PIPELINE_DISABLE_C2D_SAMPLE$
  ICCARM.CCIncludePath2: ..\tx; ..\nxd\; ..\nx_secure\; azure-sdk-for-c\sdk\core\core\inc; azure-sdk-for-c\sdk\core\core\internal; azure-sdk-for-c\sdk\iot\core\inc; azure-sdk-for-c\sdk\iot\hub\inc; azure-sdk-for-c\sdk\iot\provisioning\inc; azure-sdk-for-c\sdk\platform\noplatform\inc; ..\stm32f7xx_library; ..\azure_embedded_c_sdk; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\hub\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\core\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\provisioning\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32f746xx_ITCM_flash.icf
  group Common Source
    ../common_hardware_code/: board_setup.c es_wifi.c startup_stm32l4s5xx.s tx_initialize_low_level.s wifi.c wifi.h
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: main.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c nx_azure_iot_pnp_helpers.c nx_driver_stm32l4.c nx_driver_stm32l4.h sample_config.h sample_device_identity.c sample_network.c sample_pnp_deviceinfo_component.c sample_pnp_temperature_controller.c sample_pnp_thermostat_component.c
