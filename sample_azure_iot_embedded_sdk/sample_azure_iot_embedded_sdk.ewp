# IAR project sample_azure_iot_embedded_sdk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; WIFI_SSID=""; WIFI_PASSWORD=""; WIFI_SECURITY_TYPE=WIFI_ECN_WPA2_PSK
  ICCARM.CCIncludePath2: ..\threadx\common\inc; ..\threadx\ports\cortex_m4\iar\inc; ..\netxduo\common\inc; ..\netxduo\ports\cortex_m4\iar\inc; ..\netxduo\nx_secure\ports; ..\netxduo\crypto_libraries\inc; ..\netxduo\addons\cloud; ..\netxduo\addons\dns; ..\netxduo\addons\mqtt; ..\netxduo\addons\sntp; ..\netxduo\nx_secure\inc; ..\netxduo\nx_secure\ports; ..\stm32l4xx_lib\; ..\stm32l4xx_lib\CMSIS\Include; ..\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ..\common_hardware_code; ..\common_hardware_code\lwesp\src\include\; ..\common_hardware_code\lwesp\src\include\system\port\threadx; ..\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\netxduo\addons\azure_iot\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.bin
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F746xx; DISABLE_GUIX; TX_ENABLE_EXECUTION_CHANGE_NOTIFY; ENDPOINT=$PIPELINE_DPS_ENDPOINT$; ID_SCOPE=$PIPELINE_ID_SCOPE$; REGISTRATION_ID=$PIPELINE_REGISTRATION_ID$; HOST_NAME=$PIPELINE_HOST_NAME$; DEVICE_ID=$PIPELINE_DEVICE_ID$; DEVICE_SYMMETRIC_KEY=$PIPELINE_DEVICE_SYMMETRIC_KEY$; DEVICE_CERT=$PIPELINE_DEVICE_CERTIFICATE$; DEVICE_PRIVATE_KEY=$PIPELINE_DEVICE_PRIVATE_KEY$; USE_DEVICE_CERTIFICATE=$PIPELINE_USE_DEVICE_CERTIFICATE$; $PIPELINE_DISABLE_DPS_SAMPLE$; $PIPELINE_DISABLE_TELEMETRY_SAMPLE$; $PIPELINE_DISABLE_C2D_SAMPLE$
  ICCARM.CCIncludePath2: ..\tx; ..\nxd\; ..\nx_secure\; azure-sdk-for-c\sdk\core\core\inc; azure-sdk-for-c\sdk\core\core\internal; azure-sdk-for-c\sdk\iot\core\inc; azure-sdk-for-c\sdk\iot\hub\inc; azure-sdk-for-c\sdk\iot\provisioning\inc; azure-sdk-for-c\sdk\platform\noplatform\inc; ..\stm32f7xx_library; ..\azure_embedded_c_sdk; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\hub\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\core\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\core\inc; ..\azure_embedded_c_sdk\azure-sdk-for-c\sdk\iot\provisioning\inc
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\common_hardware_code\stm32f746xx_ITCM_flash.icf
  group Common Source
    ../common_hardware_code/: board_setup.c startup_stm32l4s5xx.s tx_initialize_low_level.s wifi.c wifi.h
  group Common Source/lwesp/src
    ../common_hardware_code/lwesp/src/lwesp/: lwesp.c lwesp_ap.c lwesp_buff.c lwesp_cli.c lwesp_conn.c lwesp_debug.c lwesp_dhcp.c lwesp_dns.c lwesp_evt.c lwesp_hostname.c lwesp_input.c lwesp_int.c lwesp_mdns.c lwesp_mem.c lwesp_parser.c lwesp_pbuf.c lwesp_ping.c lwesp_smart.c lwesp_sntp.c lwesp_sta.c lwesp_threads.c lwesp_timeout.c lwesp_unicode.c lwesp_utils.c lwesp_wps.c
    ../common_hardware_code/lwesp/src/api/: lwesp_netconn.c
  group Common Source/lwesp/system
    ../common_hardware_code/lwesp/src/system/: lwesp_ll_stm32l4s5_discovery.c lwesp_mem_threadx.c lwesp_sys_threadx_os.c
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: main.c main_test_lwesp.c netconn_client.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c nx_driver_esp_offload.c sample_azure_iot_embedded_sdk.c sample_config.h sample_device_identity.c sample_network.c
